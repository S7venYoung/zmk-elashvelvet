## boards/shields/eyelash_numpad/Kconfig.shield
```kconfig
config SHIELD_EYELASH_NUMPAD
    def_bool $(shields_list_contains,eyelash_numpad)
```
